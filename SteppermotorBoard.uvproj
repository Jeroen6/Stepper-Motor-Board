# Keil uVision project SteppermotorBoard.uvproj, settings and files
target mbed NXP LPC11U24 (ARM-ADS)
  device: LPC11U24/401 NXP (founded by Philips)
  cpu: IRAM(0x10000000-0x10001FFF) IROM(0-0x7FFF) CLOCK(12000000) CPUTYPE("Cortex-M0")
  output: SteppermotorBoard
  AfterMake: fromelf --bin -o build\SteppermotorBoard_LPC11U24.bin build\SteppermotorBoard.axf
  c flags: Optim=2 oTime=1 wLevel=2
  c define: TARGET_LPC11U24,  TARGET_M0,  TARGET_NXP,  TARGET_LPC11UXX,  TARGET_LPC11U24_401,  TOOLCHAIN_ARM_STD,  TOOLCHAIN_ARM,  __CORTEX_M0,  ARM_MATH_CM0,
  c misc: --gnu
  c include: .;  mbed-rtos;  mbed-rtos/rtx;  mbed-rtos/rtx/TARGET_M0;  mbed-rtos/rtx/TARGET_M0/TOOLCHAIN_ARM;  mbed-rtos/rtos;  USBDevice;  USBDevice/USBHID;  USBDevice/USBDevice;  USBDevice/USBAudio;  USBDevice/USBSerial;  USBDevice/USBMSD;  USBDevice/USBMIDI;  mbed;  mbed/TARGET_LPC11U24;  mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD
  memory RVCT4: ROM 0x0 size 0x8000
  memory RVCT9: RAM 0x10000000 size 0x2000
  scatter file: mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/LPC11U24.sct
  link misc: mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/system_LPC11Uxx.o
            
            mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/sys.o
            
            mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/cmsis_nvic.o
            
            mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/startup_LPC11xx.o
            
            mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/retarget.o
            
            mbed/TARGET_LPC11U24/TOOLCHAIN_ARM_STD/mbed.ar
  group src
    ./: main.cpp
    ./: CT32B0_PWM.cpp SMC.cpp USB.cpp watchdog.cpp CT32B0_PWM.h smc.h USB.h watchdog.h
  group USBDevice
    USBDevice/USBDevice/: USBHAL_KL25Z.cpp USBHAL_LPC17.cpp USBHAL_LPC11U.cpp USBHAL_LPC40.cpp USBDevice.cpp
  group USBAudio
    USBDevice/USBAudio/: USBAudio.cpp
  group USBHID
    USBDevice/USBHID/: USBMouseKeyboard.cpp USBMouse.cpp USBKeyboard.cpp USBHID.cpp
  group USBMIDI
    USBDevice/USBMIDI/: USBMIDI.cpp
  group USBMSD
    USBDevice/USBMSD/: USBMSD.cpp
  group USBSerial
    USBDevice/USBSerial/: USBCDC.cpp USBSerial.cpp
  group rtos
    mbed-rtos/rtos/: Thread.cpp Semaphore.cpp RtosTimer.cpp Mutex.cpp
  group rtx
    mbed-rtos/rtx/TARGET_M0/TOOLCHAIN_ARM/: SVC_Table.s HAL_CM0.c
    mbed-rtos/rtx/: rt_Task.c rt_System.c rt_List.c rt_Time.c rt_Semaphore.c rt_Mailbox.c rt_CMSIS.c rt_Robin.c HAL_CM.c rt_MemBox.c RTX_Conf_CM.c rt_Event.c rt_Mutex.c
